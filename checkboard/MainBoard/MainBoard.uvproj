# Keil uVision project MainBoard.uvproj, settings and files
target MainBoard (ARM-ADS)
  device: HT32F52231 Holtek
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x00000000-0x00007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: MainBoard
  c flags: Optim=1
  c define: USE_HT32_DRIVER,USE_HT32F52231_41
  c include: .\HT32F5xxxx_Driver\inc;.\Lib;.\Project;.\FunLib
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group HT32F5_Driver
    ./HT32F5xxxx_Driver/src/: ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_exti.c ht32f5xxxx_gpio.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c ht32f5xxxx_mctm.c ht32_cm0plus_misc.c
  group Lib
    ./Lib/: ht32f5xxxx_01.h system_ht32f5xxxx_01.c system_ht32f5xxxx_01.h
  group Project
    ./Lib/: startup_ht32f52231_41.s
    ./Project/: main.c bsp.c ht32f5xxxx_01_it.c delay.c
  group apiLib
    ./FunLib/: apiLib.c
