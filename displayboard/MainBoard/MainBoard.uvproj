# Keil uVision project MainBoard.uvproj, settings and files
target MainBoard (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: MainBoard +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: .\FunLib;.\Lib\CMSIS;.\Lib\CMSIS\STM32F10x;.\Lib\CMSIS\STM32F10x\startup;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Project;.\Project\log\inc;.\Project\log\port;.\Project\log\src;.\Display
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ./Lib/CMSIS/: core_cm3.c
    ./Lib/CMSIS/STM32F10x/: system_stm32f10x.c
    ./Lib/CMSIS/STM32F10x/startup/: startup_stm32f10x_hd.s
  group Lib
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FunLib
    ./FunLib/: apiLib.c
  group Project
    ./Project/: stm32f10x_it.c timer.c bsp.c main.c delay.c
    ./Project/log/port/: elog_port.c
    ./Project/log/src/: elog.c elog_utils.c
  group Display
    ./Display/: gui.c lcd_driver.c display.c
